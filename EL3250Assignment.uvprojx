# Keil uVision project EL3250Assignment.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: EL3250Assignment
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L476 USE_FULL_LL_DRIVER
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Source Group 1
    ./: main.c BSP476.c USART.c ADC.c DAC.c
software components: CMSIS:CORE 5.0.1, Compiler:I/O:STDOUT 1.2.0, Device:STM32Cube LL:ADC 1.9.0, Device:STM32Cube LL:Common 1.9.0, Device:STM32Cube LL:DAC 1.9.0, Device:STM32Cube LL:GPIO 1.9.0, Device:STM32Cube LL:RCC 1.9.0, Device:STM32Cube LL:USART 1.9.0, Device:Startup 1.3.1
